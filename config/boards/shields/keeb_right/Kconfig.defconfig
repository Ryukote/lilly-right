## config/boards/shields/keeb_right/Kconfig.defconfig
```kconfig
if SHIELD_KEEB_RIGHT

config ZMK_KEYBOARD_NAME
    default "Keeb Right"

endif # SHIELD_KEEB_RIGHT
```
